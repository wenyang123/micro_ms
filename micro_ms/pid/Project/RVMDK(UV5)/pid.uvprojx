# Keil uVision project pid.uvprojx, settings and files
target pid (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIM(encode) +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED,ARM_MATH_CM4,__CC_ARM,ARM_MATH_M
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\encode;..\..\User\uart;..\..\User\delay;..\..\User\led;..\..\User\sysc;..\..\User\buzzer;..\..\User\motor;..\..\User\ir;..\..\User\driver;..\..\User\mpu9250;..\..\Libraries\DSP_Lib;..\..\Libraries\DSP_Lib\Include;..\..\User\mathx;..\..\User\filter;..\..\User\pid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group CMISS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/encode/: encode.c
    ../../User/uart/: uart.c
    ../../User/led/: led.c
    ../../User/delay/: delay.c
    ../../User/sysc/: sysc.c
    ../../User/buzzer/: buzzer.c
    ../../User/motor/: motor.c
    ../../User/ir/: ir.c
    ../../User/driver/: driver.c
    ../../User/mpu9250/: mpu9250.c
    ../../User/mathx/: mathx.c
    ../../User/filter/: filter.c
    ../../User/pid/: pid.c
  group DOC
    ../../Doc/: README.txt
  group DSP_LIB
    ../../Libraries/DSP_Lib/: arm_cortexM4lf_math.lib
